# Keil uVision project TS_Project.uvprojx, settings and files
target APU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: APU +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\main;..\applications;..\..\OS\OS_Driver;..\..\OS\OS_Task;..\..\RTE;..\..\TYPES;..\..\RTE;..\..\LIB;..\..\BSW;..\..\Cfg\BSW_Cfg;..\..\MCAL;..\..\ext-driver;..\..\Cfg\MCAL_Cfg;..\..\APP;..\..\DRIVER\Chip_Driver\PY32F030\Library\Driver\CMSIS\Include;..\..\DRIVER\Chip_Driver\PY32F030\Library\Standard_Library\inc;..\..\DRIVER\Chip_Driver\PY32F030\User_Interface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./: main.c
    ../: OS_TASK.c
  group OS
    ../../OS/OS_Driver/: Os_BaseTimer.c Os_EvtHdl.c Os_TimerHdl.c
    ../../OS/OS_Task/: Os_TaskHdl_Lv0.c Os_TaskHdl_Lv2.c Os_TaskHdl_Lv1.c
  group RTE
    ../../RTE/: RTE.c
  group Standard_Library
    ../../DRIVER/Chip_Driver/PY32F030/Library/Standard_Library/src/: py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_comp.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c py32f0xx_ll_adc.c py32f0xx_ll_comp.c py32f0xx_ll_crc.c py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_led.c py32f0xx_ll_lptim.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_rtc.c py32f0xx_ll_spi.c py32f0xx_ll_tim.c py32f0xx_ll_usart.c py32f0xx_ll_utils.c
  group Chip_Driver
    ../../DRIVER/Chip_Driver/PY32F030/User_Interface/: py32f0xx_hal.c py32f0xx_hal_msp.c py32f0xx_it.c system_py32f0xx.c
    ../../DRIVER/Chip_Driver/PY32F030/Library/Driver/Startup/: startup_py32f030xx.s
  group MCAL
    ../../MCAL/: MCAL_RCC.c MCAL_ADC.c MCAL_DMA.c MCAL_Timer.c MCAL_NVIC.c MCAL_GPIO.c
  group MCAL-Cfg
    ../../Cfg/MCAL_Cfg/: MCAL_Cfg_ADC.c MCAL_Cfg_DMA.c MCAL_Cfg_GPIO.c
  group BSW
    ../../BSW/: BSW_Adcif.c
